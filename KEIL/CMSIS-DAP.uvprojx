# Keil uVision project CMSIS-DAP.uvprojx, settings and files
target CMSIS-DAP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS-DAP +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STM32F10x_H STM32F103xB
  c include: ..\MAIN;..\MAIN\cmsis;..\MAIN\dev;..\MAIN\wrap;..\MAIN\usb_adapter\App;..\MAIN\usb_adapter\Target;..\HAL\Inc;..\USB\Core\Inc;..\USB\Class\CustomHID\Inc;..\DAP\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ../MAIN/: main.c USBD_User_HID_0.c
    ../MAIN/dev/: system_stm32f1xx.c stm32f1xx_hal_msp.c stm32f1xx_it.c
    ./RTE/Device/STM32F103C8/: startup_stm32f10x_md.s
    ../MAIN/usb_adapter/App/: usb_device.c usbd_custom_hid_if.c usbd_desc.c
    ../MAIN/usb_adapter/Target/: usbd_conf.c
    ../MAIN/wrap/: device.c
  group HAL
    ../HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group USB
    ../USB/Class/CustomHID/Src/: usbd_customhid.c
    ../USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group DAP
    ../DAP/src/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
software components: Device:Startup 1.0.0
