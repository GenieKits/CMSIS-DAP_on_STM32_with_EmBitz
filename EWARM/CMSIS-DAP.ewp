# IAR project CMSIS-DAP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xB
  ICCARM.CCIncludePath2: ..\MAIN; ..\MAIN\wrap; ..\MAIN\cmsis; ..\MAIN\dev; ..\MAIN\usb_adapter\App; ..\MAIN\usb_adapter\Target; ..\HAL\Inc; ..\USB\Core\Inc; ..\USB\Class\CustomHID\Inc; ..\DAP\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CMSIS-DAP.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F103xB
  ICCARM.CCIncludePath2: ..\MAIN\; ..\MAIN\wrap; ..\MAIN\cmsis; ..\MAIN\dev; ..\MAIN\usb_adapter\App; ..\MAIN\usb_adapter\Target; ..\HAL\Inc; ..\USB\Core\Inc; ..\USB\Class\CustomHID\Inc; ..\DAP\Inc
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: CMSIS-DAP.hex
  group DAP/inc
    ../DAP/inc/: DAP.h
  group DAP/src
    ../DAP/src/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group HAL/Inc
    ../HAL/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_spi.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_ll_usb.h
  group HAL/Inc/Legacy
    ../HAL/Inc/Legacy/: stm32_hal_legacy.h
  group HAL/Src
    ../HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c
  group MAIN
    ./: cstartup.c
    ../MAIN/: DAP_config.h main.c main.h osObjects.h USBD_User_HID_0.c
  group MAIN/cmsis
    ../MAIN/cmsis/: core_cm3.h core_cmFunc.h core_cmInstr.h
  group MAIN/dev
    ../MAIN/dev/: stm32f103xb.h stm32f1xx.h stm32f1xx_hal_conf.h stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_it.h system_stm32f1xx.c system_stm32f1xx.h
  group MAIN/usb_adapter/App
    ../MAIN/usb_adapter/App/: usb_device.c usb_device.h usbd_custom_hid_if.c usbd_custom_hid_if.h usbd_desc.c usbd_desc.h
  group MAIN/usb_adapter/Target
    ../MAIN/usb_adapter/Target/: usbd_conf.c usbd_conf.h
  group MAIN/wrap
    ../MAIN/wrap/: cmsis_compiler.h cmsis_os2.h device.c device.h rl_usb.h
  group USB/Class/CustomHID/Inc
    ../USB/Class/CustomHID/Inc/: usbd_customhid.h
  group USB/Class/CustomHID/Src
    ../USB/Class/CustomHID/Src/: usbd_customhid.c
  group USB/Core/Inc
    ../USB/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group USB/Core/Src
    ../USB/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
